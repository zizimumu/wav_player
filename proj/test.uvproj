# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,STM32F40XX
  c include: ..\inc;..\board\inc;..\libraries\stm32f4xx_stdperiph_driver\inc;..\board\stm32Fx07_boardtest\readcmd;..\board\src;..\Third_Party\fat_fs\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c myconfig.c
  group board
    ../board/src/: led.c key.c delay.c timer.c usart.c wm8731.c sdio_sd.c
    ../src/: wavplay.c
  group periph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_sdio.c
  group X07_test
    ../board/stm32Fx07_boardtest/readcmd/: readline.c
  group FatFs
    ../Third_Party/fat_fs/src/: diskio.c ff.c
    ../Third_Party/fat_fs/src/option/: ccsbcs.c
